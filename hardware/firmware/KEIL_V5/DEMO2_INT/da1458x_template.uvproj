# Keil uVision project da1458x_template.uvproj, settings and files
target Cortex-M0 SDK - Simulator (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: DA14580 Dialog Semiconductor
  cpu: CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: da1458x_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group Source Files
    ./src/: demo.c peripherals.c
  group Include Files
    ./include/: datasheet.h global_io.h gpio.h peripherals.h core_cm0.h
  group Misc
    ./misc/: serial_out.txt
