# Keil uVision project demo3.uvproj, settings and files
target Demo3 (ARM-ADS)
  device: DA14580 Dialog Semiconductor
  cpu: CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: demo3
  c flags: Optim=1 v6Lang=1 v6LangP=1
