# Keil uVision project demo3_1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: DA14580 Dialog Semiconductor
  cpu: CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: demo3_1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
