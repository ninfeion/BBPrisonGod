# Keil uVision project ble_app_peripheral.uvprojx, settings and files
target ble_app_peripheral_580 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_peripheral_580 +hex
  c flags: Optim=4 wLevel=2
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt"
  c include: .\..\;.\..\..\..\..\..\sdk\platform\include;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk\app_modules\src\app_findme;.\..\..\..\..\..\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk\app_modules\src\app_spotar;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\ble_stack\profiles\accel;.\..\..\..\..\..\sdk\ble_stack\profiles\adc_notify;.\..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc;.\..\..\..\..\..\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc;.\..\..\..\..\..\sdk\ble_stack\profiles\anp\anps;.\..\..\..\..\..\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\basc;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass;.\..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc;.\..\..\..\..\..\sdk\ble_stack\profiles\blp\blps;.\..\..\..\..\..\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs;.\..\..\..\..\..\sdk\ble_stack\profiles\device_config;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\disc;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss;.\..\..\..\..\..\sdk\ble_stack\profiles\find\findl;.\..\..\..\..\..\sdk\ble_stack\profiles\find\findt;.\..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc;.\..\..\..\..\..\sdk\ble_stack\profiles\glp\glps;.\..\..\..\..\..\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc;.\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt;.\..\..\..\..\..\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\sdk\ble_stack\profiles\ieu;.\..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc;.\..\..\..\..\..\sdk\ble_stack\profiles\lan\lans;.\..\..\..\..\..\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\sdk\ble_stack\profiles\mpu;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\sdk\ble_stack\profiles\sample128;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\sdk\ble_stack\profiles\spota\spotar;.\..\..\..\..\..\sdk\ble_stack\profiles\sps\sps_client;.\..\..\..\..\..\sdk\ble_stack\profiles\sps\sps_server;.\..\..\..\..\..\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\..\..\..\..\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc;.\..\..\..\..\..\sdk\ble_stack\profiles\tip\tips;.\..\..\..\..\..\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\sdk\ble_stack\profiles\uds\udss;.\..\..\..\..\..\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt\wptc;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt\wpts;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt;.\..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk\platform\driver\accel;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\sdk\platform\driver\bme280;.\..\..\..\..\..\sdk\platform\driver\coex;.\..\..\..\..\..\sdk\platform\driver\coex;.\..\..\..\..\..\sdk\platform\driver\emi;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\platform\driver\i2c_BMI055;.\..\..\..\..\..\sdk\platform\driver\i2c_core;.\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk\platform\driver\intc;.\..\..\..\..\..\sdk\platform\driver\inv;.\..\..\..\..\..\sdk\platform\driver\led;.\..\..\..\..\..\sdk\platform\driver\mc3410;.\..\..\..\..\..\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk\platform\driver\rc5;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\driver\sensor;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_439;.\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\src\config;.\..\src;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;..\src\custom_profile
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk\common_project_files\misc\rom_symdef.txt  --symdefs=ble_app_peripheral_580_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../../sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../../../../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../../sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../../../sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../../../sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_patch.c
  group sdk_patches
    ./../../../../../sdk/platform/patch_code/DA14580/obj/: atts_task.obj ch_map.obj gapm_util.obj ke_task.obj smpc.obj smpc_task.obj llc.obj ke_mem.obj gapc_task.obj llc_con_update_ind.obj
    ../../../../../sdk/platform/patch_code/DA14580/obj/: atts_util.obj
  group sdk_patches_581
    ../../../../../sdk/platform/patch_code/DA14581/obj/: atts_util.obj lld.obj llm_task.obj smpc_task.obj ke_mem.obj ke_task.obj
    ./../../../../../sdk/platform/patch_code/DA14581/obj/: gapc_task.obj llc_con_update_ind.obj
  group sdk_driver
    ./../../../../../sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../../sdk/platform/driver/gpio/: gpio.c
    ./../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../../../sdk/platform/driver/battery/: battery.c
    ./../../../../../sdk/platform/driver/adc/: adc.c
    ./../../../../../sdk/platform/driver/trng/: trng.c
    ./../../../../../sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../../../sdk/platform/driver/spi/: spi.c
    ./../../../../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../../../sdk/platform/driver/uart/: uart2.c
  group sdk_ble
    ./../../../../../sdk/platform/core_modules/rf/src/: rf_580.c
    ./../../../../../sdk/ble_stack/rwble/: rwble.c
    ./../../../../../sdk/platform/core_modules/rwip/src/: rwip.c
    ./../../../../../sdk/ble_stack/host/gap/gapm/: gapm.c
  group sdk_profiles
    ./../../../../../sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../../../../../sdk/ble_stack/profiles/dis/diss/: diss.c diss_task.c
    ./../../../../../sdk/ble_stack/profiles/: prf_utils.c
    ./../../../../../sdk/ble_stack/profiles/custom/custs/: custs1.c custs1_task.c
    ./../../../../../sdk/ble_stack/profiles/custom/: custom_common.c
  group sdk_app
    ./../../../../../sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../../../sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c
    ../../../../../sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../../../../../sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ./../../../../../sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    ./../../../../../sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ./../../../../../sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ./../../../../../sdk/app_modules/src/app_spotar/: app_spotar.c app_spotar_task.c
    ./../../../../../sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../../../../../sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_timer.c
    ../../../../../sdk/app_modules/src/app_easy/: app_easy_security.c
    ./../../../../../sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
  group sdk_driver_api
    ../../../../../sdk/platform/driver/adc/: adc.h
    ../../../../../sdk/platform/driver/battery/: battery.h
    ../../../../../sdk/platform/driver/gpio/: gpio.h
    ../../../../../sdk/platform/driver/i2c_core/: i2c_core.h
    ../../../../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ../../../../../sdk/platform/driver/pwm/: pwm.h
    ../../../../../sdk/platform/driver/spi/: spi.h
    ../../../../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../../../../sdk/platform/driver/systick/: systick.h
    ../../../../../sdk/platform/driver/trng/: trng.h
    ../../../../../sdk/platform/driver/uart/: uart.h
    ../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    ../../../../../sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    ../../../../../sdk/platform/arch/: arch_api.h
    ../../../../../sdk/platform/arch/main/: arch_wdg.h
    ../../../../../sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h user_config_sw_ver.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ../src/: user_peripheral.c
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_custs1_impl.c
  group bbpg_driver_src
    ../src/bbpg_file/src/: hw_i2c.c mpu9250.c oled_dis.c oled_draw.c touch_detect.c bbpg_led.c bbpg_uart.c bbpg_alarm.c
    ../src/bbpg_file/inc/: bbpg_user_setup.h
  group ucgui_config
    ../src/ucgui/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group ucgui_antiAlias
    ../src/ucgui/GUI/AntiAlias/: GUIAAArc.c GUIAAChar.c GUIAAChar2.c GUIAAChar4.c GUIAACircle.c GUIAALib.c GUIAALine.c GUIAAPoly.c GUIAAPolyOut.c
  group ucgui_convertColor
    ../src/ucgui/GUI/ConvertColor/: LCDP111.c LCDP222.c LCDP233.c LCDP323.c LCDP332.c LCDP444_12.c LCDP444_12_1.c LCDP444_16.c LCDP555.c LCDP556.c LCDP565.c LCDP655.c LCDP8666.c LCDP8666_1.c LCDPM233.c LCDPM323.c LCDPM332.c LCDPM444_12.c LCDPM444_16.c LCDPM555.c LCDPM556.c LCDPM565.c LCDPM655.c
  group ucgui_convertMono
    ../src/ucgui/GUI/ConvertMono/: LCDP0.c LCDP2.c LCDP4.c
  group ucgui_core
    ../src/ucgui/GUI/Core/: GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectMax.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawHLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_RectsIntersect.c GUI_SaveContext.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI2DLib.c GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIUC0.c GUIVal.c GUIValf.c LCD.c LCD_API.c LCD_DrawBitmap_565.c LCD_DrawBitmap_M565.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c
  group ucgui_font
    ../src/ucgui/GUI/Font/: F4x6.c F6x8.c F08_1.c F08_ASCII.c F8x8.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c
  group ucgui_lcdDriver
    ../src/ucgui/GUI/LCDDriver/: ILI93xx.c LCDDummy.c LCDNull.c LCDWin.c
  group ucgui_memDev
    ../src/ucgui/GUI/MemDev/: GUIDEV.c GUIDEV_1.c GUIDEV_8.c GUIDEV_16.c GUIDEV_AA.c GUIDEV_Auto.c GUIDEV_Banding.c GUIDEV_Clear.c GUIDEV_CmpWithLCD.c GUIDEV_CopyFromLCD.c GUIDEV_CreateFixed.c GUIDEV_GetDataPtr.c GUIDEV_GetXSize.c GUIDEV_GetYSize.c GUIDEV_Measure.c GUIDEV_ReduceYSize.c GUIDEV_SetOrg.c GUIDEV_Usage.c GUIDEV_UsageBM.c GUIDEV_Write.c GUIDEV_WriteAlpha.c GUIDEV_WriteEx.c GUIDEV_XY2PTR.c
  group ucgui_widget
    ../src/ucgui/GUI/Widget/: BUTTON.c BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_IsPressed.c BUTTON_SelfDraw.c BUTTON_SetTextAlign.c BUTTON_StreamedBitmap.c CHECKBOX.c CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_SetBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c DIALOG.c DROPDOWN.c DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_DeleteItem.c DROPDOWN_InsertString.c DROPDOWN_ItemSpacing.c DROPDOWN_SetAutoScroll.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextHeight.c EDIT.c EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_GetNumChars.c EDIT_SetCursorAtChar.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c FRAMEWIN.c FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c GUI_ARRAY.c GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c HEADER.c HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_StreamedBitmap.c LISTBOX.c LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c MENU.c MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MULTIEDIT.c MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c PROGBAR.c PROGBAR_Create.c PROGBAR_CreateIndirect.c RADIO.c RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_Image.c RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c SCROLLBAR.c SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetValue.c SCROLLBAR_SetWidth.c SLIDER.c SLIDER_Create.c SLIDER_CreateIndirect.c TEXT.c TEXT_Create.c TEXT_CreateIndirect.c TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c WIDGET.c WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c
  group ucgui_wm
    ../src/ucgui/GUI/WM/: WM.c WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_Move.c WM_MoveChildTo.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_StayOnTop.c WM_Timer.c WM_TimerExternal.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c WMMemDev.c WMTouch.c
target ble_app_peripheral_581 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: ble_app_peripheral_581 +hex
  c flags: Optim=4 wLevel=2
  c define: __DA14581__
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\scatterfile_common_581.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk\common_project_files\misc\rom_symdef_581.txt  --symdefs=ble_app_peripheral_581_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
target ble_app_peripheral_583 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: ble_app_peripheral_583 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14583__
  c misc: as above
  c include: .\..\;.\..\..\..\..\..\sdk\platform\include;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk\app_modules\src\app_findme;.\..\..\..\..\..\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk\app_modules\src\app_spotar;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\ble_stack\profiles\accel;.\..\..\..\..\..\sdk\ble_stack\profiles\adc_notify;.\..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc;.\..\..\..\..\..\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc;.\..\..\..\..\..\sdk\ble_stack\profiles\anp\anps;.\..\..\..\..\..\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\basc;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass;.\..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc;.\..\..\..\..\..\sdk\ble_stack\profiles\blp\blps;.\..\..\..\..\..\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs;.\..\..\..\..\..\sdk\ble_stack\profiles\device_config;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\disc;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss;.\..\..\..\..\..\sdk\ble_stack\profiles\find\findl;.\..\..\..\..\..\sdk\ble_stack\profiles\find\findt;.\..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc;.\..\..\..\..\..\sdk\ble_stack\profiles\glp\glps;.\..\..\..\..\..\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc;.\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt;.\..\..\..\..\..\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\sdk\ble_stack\profiles\ieu;.\..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc;.\..\..\..\..\..\sdk\ble_stack\profiles\lan\lans;.\..\..\..\..\..\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\sdk\ble_stack\profiles\mpu;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\sdk\ble_stack\profiles\sample128;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\sdk\ble_stack\profiles\spota\spotar;.\..\..\..\..\..\sdk\ble_stack\profiles\sps\sps_client;.\..\..\..\..\..\sdk\ble_stack\profiles\sps\sps_server;.\..\..\..\..\..\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\..\..\..\..\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc;.\..\..\..\..\..\sdk\ble_stack\profiles\tip\tips;.\..\..\..\..\..\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\sdk\ble_stack\profiles\uds\udss;.\..\..\..\..\..\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt\wptc;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt\wpts;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt;.\..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk\platform\driver\accel;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\sdk\platform\driver\bme280;.\..\..\..\..\..\sdk\platform\driver\coex;.\..\..\..\..\..\sdk\platform\driver\coex;.\..\..\..\..\..\sdk\platform\driver\emi;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\platform\driver\i2c_BMI055;.\..\..\..\..\..\sdk\platform\driver\i2c_core;.\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk\platform\driver\intc;.\..\..\..\..\..\sdk\platform\driver\inv;.\..\..\..\..\..\sdk\platform\driver\led;.\..\..\..\..\..\sdk\platform\driver\mc3410;.\..\..\..\..\..\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk\platform\driver\rc5;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\driver\sensor;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_439;.\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\src\config;.\..\src;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;..\src\custom_profile;..\src\bbpg_file\inc;..\src\ucgui\Config;..\src\ucgui\GUI\Core
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk\common_project_files\misc\rom_symdef.txt  --symdefs=ble_app_peripheral_583_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
