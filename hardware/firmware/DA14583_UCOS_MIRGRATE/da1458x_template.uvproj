# Keil uVision project da1458x_template.uvproj, settings and files
target Cortex-M0 SDK - Simulator (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: DA14580 Dialog Semiconductor
  cpu: CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: da1458x_template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\startup;.\uCOS\uC-CPU\Cfg;.\uCOS\uC-CPU\Ports\IAR;.\uCOS\uC-CPU\Source;.\uCOS\uC-LIB\Cfg;.\uCOS\uC-LIB\Ports\ARM-Cortex-M3\IAR;.\uCOS\uC-LIB\Source;.\uCOS\uCOS-III\Cfg;.\uCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR;.\uCOS\uCOS-III\Source
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group uC-CPU
    ./uCOS/uC-CPU/Ports/RealView/: cpu_a.asm cpu_c.c
    ./uCOS/uC-CPU/Source/: cpu_core.c
  group uC-LIB
    ./uCOS/uC-LIB/Source/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./uCOS/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOS-III
    ./uCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./uCOS/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
