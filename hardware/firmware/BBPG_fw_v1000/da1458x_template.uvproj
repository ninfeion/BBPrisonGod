# Keil uVision project da1458x_template.uvproj, settings and files
target Cortex-M0 SDK - Simulator (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: DA14580 Dialog Semiconductor
  cpu: CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: da1458x_template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\src\uart;.\src\gpio;.\include;.\src\sw_i2c;.\src\systick;.\src\pwm;.\src\i2c;.\src\arch;.\src\arch\ll\rvds;.\src\arch\boot\rvds;.\src\arch\compiler\rvds;.\src\arch\main;.\src\include;.\src\reg;.\src\gpio;.\src\mpu9250;.\src;.\src\console;.\src\led;.\src\uart;.\src\oled_dis;.\src\touch_detect
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group Users Files
    ./src/: demo.c user_setup.h
  group Misc
    ./misc/: serial_out.txt
  group Drivers
    ./src/i2c/: hw_i2c.c
    ./src/gpio/: gpio.c
    ./src/mpu9250/: mpu9250.c
    ./src/uart/: uart.c
    ./src/console/: console.c
    ./src/led/: led.c
    ./src/systick/: systick.c
    ./src/oled_dis/: oled_dis.c
    ./src/touch_detect/: touch_detect.c
